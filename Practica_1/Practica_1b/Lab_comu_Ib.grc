options:
  parameters:
    generate_options: qt_gui
    id: Lab_comu_Ib
    output_language: python
    title: Lab_1b
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud señal TX
    start: '0'
    step: '1E-3'
    stop: '1'
    value: '500E-3'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '500E-3'
    stop: '30'
    value: '10'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: 50E6
    step: 1E6
    stop: 2.2E9
    value: 50E6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 195.312E3
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    alias: analog_const_source_x_0
    const: A
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    alias: uhd_usrp_sink_0
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
