options:
  parameters:
    generate_options: qt_gui
    id: Lab_comu_3_B
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: B
  id: variable_qtgui_range
  parameters:
    label: '# muestras por simbolo'
    start: '1'
    step: '1'
    stop: '20'
    value: '10'
  states: {}
- name: n
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    alias: analog_random_source_x_0
    max: int(math.pow(2,n))
    min: '0'
    num_samps: '1000'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    alias: blocks_add_const_vxx_0
    const: '-(math.pow(2,n)-1)/2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    alias: blocks_mu
    const: 1/math.pow(2,n)
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    alias: blocks_repeat_0
    interp: B
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters:
    alias: blocks_uchar_to_float_0
  states: {}
- name: import_0
  id: import
  parameters:
    alias: import
    imports: import math
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    alias: virtual_sink_0
    stream_id: m_t
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_repeat_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
